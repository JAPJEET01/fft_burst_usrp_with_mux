options:
  parameters:
    author: usrp
    generate_options: qt_gui
    id: dwdsfwdw
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/usrp/Music/received_data.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 737280)
    type: byte
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import serial

      class ArduinoSerialReader(gr.sync_block):
          """Custom GNU Radio block to read data from Arduino serial output"""

          def __init__(self, port='/dev/ttyACM0', baudrate=9600):
              """Initialize the block"""
              gr.sync_block.__init__(
                  self,
                  name='Arduino Serial Reader',
                  in_sig=None,
                  out_sig=[np.uint8]  # Change the output signature if necessary
              )
              self.serial_port = serial.Serial(port, baudrate)

          def work(self, input_items, output_items):
              """Read data from serial port and emit"""
              data = self.serial_port.read(512)  # Read serial data, adjust buffer size as needed
              output_items[0][:len(data)] = np.frombuffer(data, dtype=np.uint8)
              return len(data)
    baudrate: '9600'
    port: '''/dev/ttyACM0'''
  states: {}
- name: iridium_fft_burst_tagger_0_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: '1000'
    burst_pre_len: '1000'
    burst_width: '100'
    center_frequency: 98.3e6
    debug: 'False'
    fft_size: '1024'
    history_size: '512'
    max_burst_len: '100'
    max_bursts: '10'
    sample_rate: int(20e6)
    threshold: '7'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '6000'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', iridium_fft_burst_tagger_0_0, '0']
- [blocks_stream_mux_0, '0', network_tcp_sink_0, '0']
- [epy_block_1_0, '0', blocks_stream_mux_0, '0']
- [iridium_fft_burst_tagger_0_0, '0', blocks_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-655-g7d61746e
